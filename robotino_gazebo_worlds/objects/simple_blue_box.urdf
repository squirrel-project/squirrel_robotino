Commit message: updated vesion of simple box

File: robotino_gazebo_worlds/objects/simple_blue_box.urdf (robot description, URDF)
Before this commit: robot simple_blue_box, 1 links, 0 joints
Links:
- link simple_blue_box: mass 1.0 -> 2.0
